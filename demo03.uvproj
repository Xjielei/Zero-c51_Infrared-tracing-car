# Keil uVision project demo03.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: demo03 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c motordriver.c infrared_track.c movestate.c Timer.c Timer.h motordriver.h infrared_track.h movestate.h delay.c delay.h sendbit.c sendbit.h show_state.c show_state.h stdlib.h intrins.h stceeprom.c stceeprom.h
